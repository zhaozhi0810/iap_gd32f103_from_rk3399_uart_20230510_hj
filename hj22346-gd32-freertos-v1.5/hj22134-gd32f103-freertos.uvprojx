# Keil uVision project hj22134-gd32f103-freertos.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103VB GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: hj22134-gd32f103-freertos +hex
  AfterMake: fromelf --bin -o ./temp/@L.bin ./Objects/@L.axf
  AfterMake: tools/combin temp/gd32f103-iap.bin temp/hj22134-gd32f103-freertos.bin output/hj22134-gd32f103-freertos.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F10X_MD
  c include: .\src\freertos\include;.\src;.\src\freertos\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8006000 size 0x1a000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user_apps
    ./src/: main.c led_show_work.c uart.c uart_debug_handle.c iic.c iic_app.c matrix_keys.c Nca9555.c systick.c gd32f10x_it.c uart_conect_cpu_handler.c lt9211.c GPIOs.c lcd_pwm.c internal_temp.c hard_wtd.c key_light.c my_task_info.c ota-uart.c
  group freertos
    ./src/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./src/freertos/portable/RVDS/ARM_CM3/: port.c
    ./src/freertos/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 5.3.0, Device:GD32F10x_StdPeripherals:ADC 2.0.1, Device:GD32F10x_StdPeripherals:EXTI 2.0.1, Device:GD32F10x_StdPeripherals:FMC 2.0.1, Device:GD32F10x_StdPeripherals:FWDGT 2.0.1, Device:GD32F10x_StdPeripherals:GPIO 2.0.1, Device:GD32F10x_StdPeripherals:MISC 2.0.1, Device:GD32F10x_StdPeripherals:PMU 2.0.1, Device:GD32F10x_StdPeripherals:RCU 2.0.1, Device:GD32F10x_StdPeripherals:TIMER 2.0.1, Device:GD32F10x_StdPeripherals:USART 2.0.1, Device:GD32F10x_libopt 2.0.1, Device:Startup 2.0.1
